# Keil uVision project XC-OS.uvprojx, settings and files
target XC-OS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,ARDUINO=111,LV_CONF_INCLUDE_SIMPLE
  c include: ..\ArduinoAPI;..\Core;..\Libraries\Adafruit_GFX_Library;..\Libraries\TFT_ILI9488;..\Libraries\GT911;..\Libraries\StrPrinter;..\Libraries\lvgl;..\Libraries\lvgl\lv_examples;..\Libraries\FreeRTOS;..\Libraries\FreeRTOS\Source\include;..\Libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Source\Basic;..\Source\GUI;..\Source\LuaScript;..\Source\Module;..\Libraries\lua-5.3.2\src;..\Libraries\SdFat\src\FatLib;..\Libraries\SdFat\src\SdCard;..\Libraries\SdFat\src\SpiDriver;..\Libraries\SdFat\src;..\Libraries\NRF;..\Libraries\IP5108;..\Libraries\LightGUI\PageManager;..\Libraries\FifoQueue;..\Libraries\WavDecoder;..\Libraries\I2Cdev;..\Libraries\MPU6050;..\Libraries\XTRC_Analyzer;..\Source\Communication;..\Libraries\BV_Player
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Basic
    ../Source/Basic/: SysConfig.h TasksManage.h main.cpp
  group GUI
    ../Source/GUI/: DisplayPrivate.h DisplayBasic.cpp DisplayBar.cpp DisplayWidget.cpp DisplayError.cpp lv_conf.h lv_port_disp.cpp lv_port_fs.cpp lv_ext_func.cpp Page_EXAMPLE.cpp Page_Home.cpp Page_LuaScript.cpp Page_BattInfo.cpp Page_BattInfoOld.cpp Page_Settings.cpp Page_SetDisplay.cpp Page_FileExplorer.cpp Page_SubAPPs.cpp Page_TextEditor.cpp Page_AppBgManager.cpp Page_WavPlayer.cpp Page_BvPlayer.cpp
  group GUI\IMG
    ../Source/GUI/IMG/: ImgCode.c ImgEditor.c ImgExplorer.c ImgFiles.c ImgGame.c ImgInternet.c ImgMessage.c ImgPlay.c ImgSettings.c ImgSubApps.c ImgUSB.c ImgVideo.c ImgMusic.c
  group Module
    ../Source/Module/: Audio.cpp Brightness.cpp IMU.cpp Motor.cpp Power.cpp Text.cpp Xtrc.cpp
  group Communication
    ../Source/Communication/: ComBasic.cpp ComHandshake.cpp
  group LuaScript
    ../Source/LuaScript/: LuaBasic.cpp LuaScript.cpp LuaTime.cpp LuaGPIO.cpp LuaModule.cpp LuaCom.cpp
  group lua-5.3.2
    ../Libraries/lua-5.3.2/src/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lua.c luac.c lundump.c lutf8lib.c lvm.c lzio.c
  group littlevGL
    ../Libraries/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Libraries/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../Libraries/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../Libraries/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Libraries/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../Libraries/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../Libraries/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group FreeRTOS
    ../Libraries/FreeRTOS/: FreeRTOSConfig.h
    ../Libraries/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c cpu_utils.c printf-stdarg.c
    ../Libraries/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../Libraries/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group SdFat
    ../Libraries/SdFat/src/FatLib/: FatFile.cpp FatFileLFN.cpp FatFilePrint.cpp FatFileSFN.cpp FatVolume.cpp FmtNumber.cpp fstream.cpp istream.cpp ostream.cpp StdioStream.cpp
    ../Libraries/SdFat/src/SdCard/: SdSpiCard.cpp SdSpiCardEX.cpp
    ../Libraries/SdFat/src/SpiDriver/: SdSpiSTM32.cpp
    ../Libraries/SdFat/src/: MinimumSerial.cpp
  group Libraries
    ../ArduinoAPI/: SPI.cpp
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/BV_Player/: BV_Player.cpp
    ../Libraries/GT911/: GT911.cpp GTIIC.cpp touch.cpp
    ../Libraries/IP5108/: IP5108.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/NRF/: NRF.cpp
    ../Libraries/StrPrinter/: StrPrinter.cpp
    ../Libraries/TFT_ILI9488/: TFT_ILI9488.cpp
    ../Libraries/LightGUI/PageManager/: PageManager.cpp
    ../Libraries/WavDecoder/: wav_decoder.cpp
    ../Libraries/XTRC_Analyzer/: XTRC_Analyzer.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp Stream.cpp WString.cpp WMath.cpp HardwareSerial.cpp WireBase.cpp Wire.cpp Tone.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c rng.c timer.c
    ../CORE/: delay.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:CRC 1.3.0, Device:StdPeriph Drivers:DAC 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RNG 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
